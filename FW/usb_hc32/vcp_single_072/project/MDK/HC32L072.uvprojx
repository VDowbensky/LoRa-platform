# Keil uVision project HC32L072.uvprojx, settings and files
target HC32L072_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L072JATA HDSC
  pack: HDSC.HC32L07X.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HC32L072 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1
  c include: ..\..\common;..\source;..\..\usb_lib\ctl_drv;..\..\usb_lib\device_core;..\source;..\source\other;..\..\hardware_driver\inc;..\..\fat;..\..\usb_lib\device_class\cdc\inc;..\retarget;..\cli
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l07x.s
    ../../common/: system_hc32l07x.c
  group usr_app
    ../source/: main.c app_cli.c
  group usb_device
    ../../usb_lib/device_core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../usb_lib/device_class/cdc/src/: usbd_cdc_core.c
  group usb_app
    ../source/: usbd_desc.c usbd_urs.c usb_bsp.c usbd_cdc_com.c
  group usb_core
    ../../usb_lib/ctl_drv/: usb_core.c usb_dcd.c usb_dcd_int.c
  group doc
    ../../: Readme.txt
  group retarget
    ../retarget/: retarget.c
  group cli
    ../cli/: command_interpreter.c
software components: CMSIS:CORE 5.6.0
