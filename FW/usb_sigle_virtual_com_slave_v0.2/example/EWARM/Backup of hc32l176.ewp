# IAR project Backup of hc32l176.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\common; ..\source; ..\..\usb_lib\ctl_drv; ..\..\usb_lib\device_class\hid; ..\..\usb_lib\device_core
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32l176.srec
  ILINK.IlinkOutputFile: hc32l176.out
  ILINK.IlinkIcfFile: config\hc32l176.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  group common
    ./: startup_hc32l176.s
    ../../common/: system_hc32l176.c
  group source
    ../source/: main.c usb_bsp_L176.c usbd_desc.c usbd_urs.c
  group usb_lib/ctl_drv
    ../../usb_lib/ctl_drv/: usb_core.c usb_dcd.c usb_dcd_int.c usb_otg.c
  group usb_lib/device_class
    ../../usb_lib/device_class/hid/: usbd_hid_core.c
  group usb_lib/device_core
    ../../usb_lib/device_core/: usbd_core.c usbd_ioreq.c usbd_req.c
