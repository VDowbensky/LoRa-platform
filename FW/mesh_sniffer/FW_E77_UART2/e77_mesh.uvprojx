# Keil uVision project e77_mesh.uvprojx, settings and files
target stm32wle5 (6240000::V6.24::ARMCLANG)
  device: STM32WLE5CCUx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: e77_sniffer +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_CM4,STM32WLE5xx,USE_FULL_LL_DRIVER
  c include: .\app;.\cli;.\mesh;.\periph;.\radiodriver;.\radiofunc;.\radiointerface;.\radioproc;.\stm32wle5;.\stm32wle5_lib\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  group user
    ./app/: app_cli.c bsp.c main.c retarget.c stm32wlxx_it.c
  group startup
    ./stm32wle5/: system_stm32wlxx.c startup_stm32wle5xx.s
  group lib
    ./stm32wle5_lib/Src/: stm32wlxx_ll_adc.c stm32wlxx_ll_exti.c stm32wlxx_ll_gpio.c stm32wlxx_ll_pwr.c stm32wlxx_ll_rcc.c stm32wlxx_ll_tim.c stm32wlxx_ll_usart.c stm32wlxx_ll_utils.c stm32wlxx_ll_spi.c
  group peripherals
    ./periph/: adc.c delay.c flash.c gpio.c subghz.c uart.c
  group radio
    ./radiofunc/: radio_func.c userdata_defs.c
    ./radiodriver/: sx126x.c sx126x_proc.c
    ./radiointerface/: sx126x_interface.c
    ./mesh/: mesh_packet.c
    ./radioproc/: radio_proc.c
  group cli
    ./cli/: command_interpreter.c
