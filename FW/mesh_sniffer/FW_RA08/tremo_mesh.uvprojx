# Keil uVision project tremo_mesh.uvprojx, settings and files
target asr6601 (6230000::V6.23::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: tremo_sniffer +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\app;.\chip;.\cli;.\lib\inc;.\mesh;.\periph;.\radiodriver;.\radiofunc;.\radiointerface;.\radioproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./app/: app_cli.c main.c bsp.c retarget.c tremo_it.c
  group startup
    ./chip/: startup_tremo.s system_tremo.c
  group lib
    ./lib/src/: tremo_adc.c tremo_bstimer.c tremo_crc.c tremo_dac.c tremo_delay.c tremo_dma.c tremo_flash.c tremo_gpio.c tremo_i2c.c tremo_i2s.c tremo_iwdg.c tremo_lcd.c tremo_lptimer.c tremo_lpuart.c tremo_pwr.c tremo_rcc.c tremo_rtc.c tremo_spi.c tremo_system.c tremo_timer.c tremo_wdg.c tremo_uart.c
  group peripherals
    ./periph/: gpio.c uart.c lorac.c flash.c adc.c i2c.c ustimer.c
  group radio
    ./radiofunc/: radio_func.c userdata_defs.c
    ./radiodriver/: sx126x.c sx126x_proc.c
    ./radioproc/: radio_proc.c
    ./radiointerface/: sx126x_interface.c
    ./mesh/: mesh_packet.c
  group cli
    ./cli/: command_interpreter.c
