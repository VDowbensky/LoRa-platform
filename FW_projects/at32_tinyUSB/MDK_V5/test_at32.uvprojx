# Keil uVision project test_at32.uvprojx, settings and files
target M665FW_AT32 (6240000::V6.24::ARMCLANG)
  device: -AT32F413CBT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.1.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_at32 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: AT32F413CBT7,USE_STDPERIPH_DRIVER,CFG_TUD_ENABLED=1
  c include: ..\app;..\cli;..\libraries\drivers\inc;..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\mesh;..\middlewares\usbd_class\cdc;..\middlewares\usbd_drivers\inc;..\periph;..\SSD1306;..\radiohal;..\radioproc;..\radiofunc;..\..\radiodriver\llcc68;..\..\radiodriver\lr11xx;..\..\radiodriver\lr20xx;..\..\radiodriver\pan3029;..\..\radiodriver\sx126x;..\..\radiodriver\sx128x;..\..\radiodriver\sx127x;..\tinyUSB\hw;..\tinyUSB;..\tinyUSB\src\class\cdc;..\tinyUSB\src\common;..\tinyUSB\src\device;..\tinyUSB\src;..\tinyUSB\src\portable\st\stm32_fsdev
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group periph
    ../periph/: at32f413_int.c at32f413_wk_config.c rtc.c wk_adc.c wk_debug.c wk_exint.c wk_gpio.c wk_rtc.c wk_spi.c wk_system.c wk_usart.c wk_wdt.c wk_usbfs.c
  group firmware
    ../libraries/drivers/src/: at32f413_acc.c at32f413_adc.c at32f413_bpr.c at32f413_can.c at32f413_crc.c at32f413_crm.c at32f413_debug.c at32f413_dma.c at32f413_exint.c at32f413_flash.c at32f413_gpio.c at32f413_i2c.c at32f413_misc.c at32f413_pwc.c at32f413_rtc.c at32f413_sdio.c at32f413_spi.c at32f413_tmr.c at32f413_usart.c at32f413_usb.c at32f413_wdt.c at32f413_wwdt.c
  group cmsis
    ./: startup_at32f413.s
    ../libraries/cmsis/cm4/device_support/: system_at32f413.c
  group cli
    ../cli/: command_interpreter.c
  group app
    ../app/: app_cli.c retarget.c bsp.c flash.c main.c keypad.c menu.c num_input.c test_packet.c ring_buffer.c
    ../mesh/: meshtastic.c meshcore.c
  group SSD1306
    ../SSD1306/: gui.c ssd1306.c ssd1306_interface.c test.c
  group radiofunc
    ../radiofunc/: radio_func.c userdata_defs.c
  group radioproc
    ../radioproc/: lr112x_proc.c pan_proc.c radio_proc.c sx126x_proc.c sx128x_proc.c lr202x_proc.c sx127x_proc.c
  group lr11xx
    ../../radiodriver/lr11xx/: lr11xx_bootloader.c lr11xx_crypto_engine.c lr11xx_driver_version.c lr11xx_gnss.c lr11xx_lr_fhss.c lr11xx_radio.c lr11xx_radio_timings.c lr11xx_regmem.c lr11xx_rttof.c lr11xx_system.c lr11xx_wifi.c lr11xx_hal.c
  group lr20xx
    ../../radiodriver/lr20xx/: lr20xx_driver_version.c lr20xx_radio_bluetooth_le.c lr20xx_radio_bpsk.c lr20xx_radio_common.c lr20xx_radio_fifo.c lr20xx_radio_flrc.c lr20xx_radio_fsk.c lr20xx_radio_lora.c lr20xx_radio_lr_fhss.c lr20xx_radio_ook.c lr20xx_radio_oqpsk_15_4.c lr20xx_radio_wi_sun.c lr20xx_radio_wm_bus.c lr20xx_radio_z_wave.c lr20xx_regmem.c lr20xx_rttof.c lr20xx_system.c lr20xx_workarounds.c lr20xx_hal.c
  group pan30xx
    ../../radiodriver/pan3029/: pan_rf.c
  group sx128x
    ../../radiodriver/sx128x/: sx128x.c sx128x_hal.c
  group radio_hal
    ../radiohal/: pan_interface.c lr11xx_interface.c lr20xx_interface.c sx126x_interface.c sx128x_interface.c sx127x_interface.c
  group sx126x
    ../../radiodriver/sx126x/: lr_fhss_mac.c sx126x.c sx126x_bpsk.c sx126x_driver_version.c sx126x_hal.c sx126x_lr_fhss.c
  group tinyUSB
    ../tinyUSB/src/: tusb.c
    ../tinyUSB/: usb_descriptors.c usb_task.c
    ../tinyUSB/src/device/: usbd.c usbd_control.c
    ../tinyUSB/src/common/: tusb_fifo.c
    ../tinyUSB/src/class/cdc/: cdc_device.c
    ../tinyUSB/hw/: at32f413_clock.c
    ../tinyUSB/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c fsdev_common.c
